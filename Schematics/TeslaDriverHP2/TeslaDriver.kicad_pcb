# Repository kavionic/TeslaDriver

## KiCad design Schematics/TeslaDriverHP2/TeslaDriver.kicad_pcb

Parts:
C1, C2, C3, C4: 1000u/63V; C_Radial_D16_L25_P7.5
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36: 2.2u/100V; C_1210
C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68: 3n9/250V; C_0805
D1, D2, D3, D4: STPS30SM120S; TO-220
D5: LED 0805 GREEN; LED_0805
HS1, HS2: HEATSINK; Heatsink12Fin73x60x25
M1, M2, M3, M4: MountingHole; MH7x3
P1: PWR_IN+; TermBlock6.35mm2P
P2: PWR_S; TermBlock6.35mm2P
P3: PWR_GND; TermBlock6.35mm2P
P4: GDriver1H; SimpleGateDriver
P5: PWR_OUT_L1_A; TermBlock6.35mm2P
P6: OUTL_CTIN; CurrentSensConnector
P7: OUTL_CTOUT; CurrentSensConnector
P8: PWR_OUT_L1_B; TermBlock6.35mm2P
P9: GDriver1L; SimpleGateDriver
P10: GDriver2H; SimpleGateDriver
P11, P12: PWR_OUT_L2_A; TermBlock6.35mm2P
P13: GDriver2L; SimpleGateDriver
P14: CUR_SENS_I1; PinHeader_1x02
P15: CUR_SENS_I2; PinHeader_1x02
P16: CUR_SENSE; PinHeader_1x02
Q1, Q2, Q3, Q4: IRFP4310ZPbF; TO-247
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 1; R_2512
R17, R18: 4k7; R_1206
T1: CurrentTrans3P; CurrentTrans3P27x10

Connections:
+24V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, D1.2 (K), D3.2 (K), P1.1, P1.2, P2.1, P4.2 (Drain), P10.2 (Drain), Q1.2 (D), Q3.2 (D), R1.2, R2.2, R3.2, R4.2, R9.2, R10.2, R11.2, R12.2, R17.1
/CUR_SENSA1: P14.1, T1.1
/CUR_SENSA2: P14.2, T1.3
/CUR_SENSB1: P15.1, P16.1
/CUR_SENSB2: P15.2, P16.2
/OUTL1: C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, D1.1 (A1), D1.3 (A2), D2.2 (K), P4.1 (Source), P6.1, P6.2, P6.3, P6.4, P6.5, P9.2 (Drain), Q1.3 (S), Q2.2 (D)
/OUTL1S: P5.1, P5.2, P7.1, P7.2, P7.3, P7.4, P7.5, P8.1, P8.2
/OUTL2: C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, D3.1 (A1), D3.3 (A2), D4.2 (K), P10.1 (Source), P11.1, P11.2, P12.1, P12.2, P13.2 (Drain), Q3.3 (S), Q4.2 (D)
GNDPWR: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, D2.1 (A1), D2.3 (A2), D4.1 (A1), D4.3 (A2), D5.1 (K), P2.2, P3.1, P3.2, P9.1 (Source), P13.1 (Source), Q2.3 (S), Q4.3 (S), R5.2, R6.2, R7.2, R8.2, R13.2, R14.2, R15.2, R16.2
unnamed: C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, R1.1, R2.1, R3.1, R4.1
unnamed: C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, R5.1, R6.1, R7.1, R8.1
unnamed: C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, R9.1, R10.1, R11.1, R12.1
unnamed: C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, R13.1, R14.1, R15.1, R16.1
unnamed: D5.2 (A), R18.2
unnamed: P4.3 (Gate), Q1.1 (G)
unnamed: P9.3 (Gate), Q2.1 (G)
unnamed: P10.3 (Gate), Q3.1 (G)
unnamed: P13.3 (Gate), Q4.1 (G)
unnamed: R17.2, R18.1

Board: 2 copper layers, 100.0 x 100.0 mm, 118 parts (16 on the bottom side), 19 nets.

## KiCad design Schematics/TeslaController/TeslaController.kicad_pcb

Parts:
C1, C5: 100u/25V; c_elec_6.3x7.7
C2, C3, C6, C7, C8, C11, C14, C17, C18, C19, C20, C22: 100n; C_0603
C4, C10, C15, C21: 1n; C_0603
C9, C13: 10p; C_0603
C12, C16: 100u/10V; c_elec_5x5.7
D1: BZX384-C3V6; SOD-323
D2, D3: BAT54S; SOT-23
IC1: ATXMEGA256A3-A; TQFP-64_14x14mm_Pitch0.8mm
L1: 10u; L_1206
P1: PWR_IN; PinHeader_1x03
P2: PWR_OUT1; PinHeaderMale_2x03
P3: ESP-12E
P4: ISP; PinHeaderMale_2x03
P5: DEBUG; PinHeader_1x04
P6: BUZZER; PiezoBuzzer_17mm_SMD
P7: EXPANSION; PinHeaderMale_2x04
P8: FAN1; PinHeader_1x04
P9: FAN2; PinHeader_1x04
P10: MicroSD
P11: KEYBOARD; PinHeaderMale_2x04
P12: INVERTER; PinHeaderMale_2x08
P13: DISPLAY; PinHeaderMale_2x06
P14: INV_EN; PinHeader_1x03
P15: TEMP1; PinHeader_1x03
P16: TEMP2; PinHeader_1x03
P17: CURRENT_SENS; PinHeaderMale_2x03
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9: BSS138; SOT-23
R1, R2, R3: 10k; R_0603
R4: 620; R_0603
R5: 3k6; R_0603
R6: 6k8; R_0603
R7, R9, R12, R32: 1k; R_0603
R8: 20k; R_0603
R10, R29: 150; R_0603
R11: 68k; R_0603
R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R33, R34: 4k7; R_0603
R30: 470; R_0603
R31: 910; R_0603
RV1: 10k; Potentiometer_Tri5x5
U1: AP1117; SOT-223
U2: AP1117D50; SOT-223
U3: AP1117D33; SOT-223
U4: TL431DBZ; SOT-23
Y1: DSX321SH; Crystal-3225

Connections:
+3.3VADC: C14.1, IC1.61 (AVCC), L1.2
+3V3: C2.2, C3.1, C6.1, C7.1, C8.1, C11.1, C16.1, C19.2, C20.2, C22.2, D1.1 (K), D2.2 (K), D3.2 (K), IC1.15 (VCC), IC1.25 (VCC), IC1.35 (VCC), IC1.45 (VCC), IC1.53 (VCC), L1.1, P2.3, P3.8 (Vcc), P4.4, P5.4, P7.1, P10.4 (Vcc), P11.2, P12.12, P14.3, P15.3, P16.3, P17.5, Q3.1 (G), Q4.1 (G), Q5.1 (G), Q6.1 (G), Q7.1 (G), Q8.1 (G), Q9.1 (G), R1.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R29.1, R33.1, R34.1, U3.2 (VO), U3.4 (VO)
+5V: C12.1, P2.4, P7.2, P11.3, P13.2, P13.11, R6.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, RV1.3, U2.2 (VO), U2.4 (VO), U3.3 (VI)
+12V: C1.1, C17.2, C18.2, P1.2, P2.5, P7.3, P8.2, P9.2, P12.10, P17.6, R8.1, U1.3 (VI)
+48V: P1.3, P2.6, R11.1
/BUZZER1: IC1.31 (PD5/OC1B/XCK1/MOSI), P6.1
/BUZZER2A: IC1.30 (PD4/OC1A/~SS~), R10.2
/BUZZER2B: P6.2, R10.1
/DEBUG_RX: IC1.38 (PE2/OC0C/RXD0), P5.2
/DEBUG_TX: IC1.39 (PE3/OC0D/TXD0), P5.3
/EXP_MISO: IC1.42 (PE6/RXD1/MISO/TOSC2), P7.7
/EXP_MOSI: IC1.41 (PE5/OC1B/XCK1/MOSI), P7.8
/EXP_SCK: IC1.43 (PE7/TXD1/SCK/TOSC1), P7.5
/GatePWM1H: IC1.16 (SDA/~OC0ALS~/OC0A/PC0), P12.4
/GatePWM1L: IC1.17 (SCL/XCK0/OC0AHS/OC0B/PC1), P12.2
/GatePWM2H: IC1.19 (TXD0/OC0BHS/OC0D/PC3), P12.8
/GatePWM2L: IC1.18 (RXD0/~OC0BLS~/OC0C/PC2), P12.6
/LCD_DB4: IC1.62 (AREFA/AC0/ADC0/PA0), Q6.2 (S), R18.2
/LCD_DB4_5V: P13.7, Q6.3 (D), R25.2
/LCD_DB5: IC1.63 (AC1/ADC1/PA1), Q5.2 (S), R17.2
/LCD_DB5_5V: P13.8, Q5.3 (D), R24.2
/LCD_DB6: IC1.64 (AC2/ADC2/PA2), Q4.2 (S), R16.2
/LCD_DB6_5V: P13.9, Q4.3 (D), R23.2
/LCD_DB7: IC1.1 (AC3/ADC3/PA3), Q3.2 (S), R15.2
/LCD_DB7_5V: P13.10, Q3.3 (D), R22.2
/LCD_E_5V: P13.6, Q7.3 (D), R26.2
/LCD_RS: IC1.7 (AC1/ADC1/PB1), Q9.2 (S), R21.2
/LCD_RS_5V: P13.4, Q9.3 (D), R28.2
/LCD_RW: IC1.6 (AREFB/AC0/ADC0/PB0), Q8.2 (S), R20.2
/LCD_RW_5V: P13.5, Q8.3 (D), R27.2
/PDI_CLK: IC1.57 (~RESET~/PDI_CLK), P4.5
/PDI_DATA: IC1.56 (PDI_DATA), P4.1
/ROT_ENC1: IC1.12 (TCK/AC6/ADC6/PB6), P11.4
/ROT_ENC2: IC1.13 (TDO/AC0OUT/AC7/ADC7/PB7), P11.5
/SD_CARD_DETECT: IC1.28 (RXD0/OC0C/PD2), P10.9 (CD)
/SD_CS: IC1.20 (~SS~/~OC0CLS~/OC1A/PC4), P10.2 (CD/DATA3/CS)
/SD_MISO: IC1.22 (MISO/RXD1/~OC0DLS~/PC6), P10.7 (DATA0/DO)
/SD_MOSI: IC1.23 (EVOUT/CLKOUT/SCK/TXD1/OC0DHS/PC7), P10.3 (CMD/DI)
/SD_SCK: IC1.21 (MOSI/XCK1/OC0CHS/OC1B/PC5), P10.5 (CLK/SCLK)
/WIFI_RESET: IC1.51 (PF5), P3.1 (RST)
/WIFI_RX: IC1.54 (PF6), P3.22 (TXD0)
/WIFI_TX: IC1.55 (PF7), P3.21 (RXD0)
/XTAL1: C13.1, IC1.59 (PR1/XTAL1), Y1.1 (X1)
/XTAL2: C9.1, IC1.58 (PR0/XTAL2), Y1.3 (X2)
CURSENS_L: D3.3 (COM), IC1.8 (DAC0/AC2/ADC2/PB2), R32.1
CURSENS_N: C21.1, IC1.11 (TDI/AC5/ADC5/PB5), P17.2, R30.2, R31.1
FAN1_PWM: IC1.26 (OC0A/PD0), Q1.1 (G)
FAN1_TACH: IC1.36 (PE0/OC0A/SDA), P8.3, R13.2
FAN2_PWM: IC1.27 (XCK0/OC0B/PD1), Q2.1 (G)
FAN2_TACH: IC1.37 (PE1/OC0B/XCK0/SCL), P9.3, R14.2
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.1, C20.1, C21.2, C22.1, D1.2 (A), D2.1 (A), D3.1 (A), IC1.14 (GND), IC1.24 (GND), IC1.34 (GND), IC1.44 (GND), IC1.52 (GND), IC1.60 (GND), P1.1, P2.1, P2.2, P3.15 (GND), P4.6, P5.1, P7.4, P7.6, P8.1, P9.1, P10.6 (GND), P10.10 (GND), P10.11 (GND), P10.12 (GND), P10.13 (GND), P11.1, P12.1, P12.3, P12.5, P12.7, P12.9, P12.11, P12.13, P13.1, P13.12, P14.1, P15.1, P16.1, P17.1, Q1.2 (S), Q2.2 (S), R2.2, R5.2, R7.2, R9.2, R12.2, R31.2, RV1.1, U2.1 (GND/ADJ), U3.1 (GND/ADJ), U4.3 (A)
GateEnable: P12.14, P14.2
KBD1: IC1.40 (PE4/OC1A/~SS~), P11.6
KBD2: IC1.32 (PD6/RXD1/MISO), P11.7
KBD3: IC1.33 (PD7/TXD1/SCK/CLKOUT/EVOUT), P11.8
LCD_E: IC1.50 (PF4), Q7.2 (S), R19.2
unnamed: C5.1, R4.1, U1.2 (VO), U1.4 (VO), U2.3 (VI)
unnamed: IC1.9 (DAC1/AC3/ADC3/PB3), IC1.10 (TMS/AC4/ADC4/PB4)
unnamed: P3.3 (EN), R1.2
unnamed: P3.16 (GPIO15), R2.1
unnamed: P3.18 (GPIO0), R3.1
unnamed: P8.4, Q1.3 (D)
unnamed: P9.4, Q2.3 (D)
unnamed: P13.3, RV1.2
unnamed: P17.3, R32.2
unnamed: R4.2, R5.1, U1.1 (GND/ADJ)
unnamed: R29.2, R30.1, U4.1 (K), U4.2 (REF)
SENS_5V: C4.1, IC1.3 (AC5/ADC5/PA5), R6.2, R7.1
SENS_12V: C10.1, IC1.4 (AC6/ADC6/PA6), R8.2, R9.1
SENS_48V: C15.1, IC1.5 (AC0OUT/AC7/ADC7/PA7), R11.2, R12.1
TEMP_EXT1: IC1.48 (PF2/OC0C/RXD0), P15.2, R33.2
TEMP_EXT2: IC1.49 (PF3/OC0D/TXD0), P16.2, R34.2
TEMP_MOSFET1: IC1.46 (PF0/OC0A), P12.15
TEMP_MOSFET2: IC1.47 (PF1/OC0B/XCK0), P12.16
WIFI_FLASH: IC1.29 (TXD0/OC0D/PD3), R3.2
ZERO_DETECT: D2.3 (COM), IC1.2 (AC4/ADC4/PA4), P17.4

Notes on the sheet:
1.65V
8.5V
MAX=7.8V
MAX=21V
MAX=69V

Board: 2 copper layers, 71.0 x 95.0 mm, 93 parts (0 on the bottom side), 76 nets.

## KiCad design Schematics/TeslaDriverHP/DualGateDriver.kicad_pcb

Parts:
C1, C7: NP; C_0603
C2, C3, C4: 1u; C_0603
C5, C6, C8, C10, C11, C12: 100n; C_0603
C9, C13: 10u; C_1206
D1, D3: ZMY12; MELF_Standard
D2, D5: SS210; Diode-SMA_Standard
D4, D6: DZ2J130M0L; SMini2-F5-B
M1, M2: MountingHole; MH6
R1, R2, R9, R10: 1; R_1206
R3, R4, R6, R8: 3R9; R_1206
R5, R7: NP; R_0603
U1, U4: GateDriver; GateDriverSub
U2: L78L05ACD; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: SI8233; SOIC-16_7.5x10.3mm_Pitch1.27mm
U5, U6: NXE2S1212MC; NXE2_DCDC

Connections:
+5V: C4.1, C5.1, C6.1, R5.1, U2.1 (VOUT), U3.3 (VDDI), U3.8 (VDDI)
+12V: C2.1, C3.1, C10.1, C11.1, U1.3 (Vdd), U2.8 (VIN), U4.3 (Vdd), U5.3 (+Vin), U6.3 (+Vin)
DT: R5.2, R7.1, U3.6 (DT)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C10.2, C11.2, R7.2, U1.4 (GND), U2.2 (GND), U2.3 (GND), U2.6 (GND), U2.7 (GND), U3.4 (GNDI), U4.4 (GND), U5.1 (-Vin), U6.1 (-Vin)
GNDH: C1.2, C8.2, C9.2, D1.2 (A), D4.2 (A), U1.2 (OUT-), U3.14 (GNDA), U5.7 (-Vout)
GNDL: C7.2, C12.2, C13.2, D3.2 (A), D6.2 (A), U3.9 (GNDB), U4.2 (OUT-), U6.7 (-Vout)
INH: U1.5 (IN), U3.1 (INA)
INL: U3.2 (INB), U4.5 (IN)
OUTH+: C1.1, D1.1 (K), R1.2, R2.2, R3.2, R4.2, U1.1 (OUT+)
OUTH+a: D2.1 (K), R3.1, R4.1, U3.15 (VOA)
OUTH+b: D2.2 (A), R1.1, R2.1
OUTL+: C7.1, D3.1 (K), R6.2, R8.2, R9.2, R10.2, U4.1 (OUT+)
OUTL+a: D5.1 (K), R6.1, R8.1, U3.10 (VOB)
OUTL+b: D5.2 (A), R9.1, R10.1
VDDH: C8.1, C9.1, D4.1 (K), U3.16 (VDDA), U5.8 (+Vout)
VDDL: C12.1, C13.1, D6.1 (K), U3.11 (VDDB), U6.8 (+Vout)
~EN: U3.5 (~EN), U4.6 (EN)

Board: 2 copper layers, 64.0 x 23.0 mm, 37 parts (0 on the bottom side), 17 nets.

## KiCad design Schematics/TeslaDriverHP/GateDriver.kicad_pcb

Parts:
C1, C6: NP; C_0603
C2, C3, C7, C8, C11: 100n; C_0603
C4, C5, C9, C10: 1u; C_0603
D1, D2: SS210; Diode-SMA_Standard
D3, D4: ZMY12; MELF_Standard
M1: MountingHole; MH6
R1, R3: 4; R_1206
R2, R4: 1; R_1206
T1: GateTR10x4; GateTR10x4_HV
U1: NCP81071A; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: GateDriver; GateDriverSub

Connections:
+12V: C9.1, C10.1, C11.1, U1.6, U2.3 (Vdd)
EN: U1.8, U2.6 (EN)
GND: C9.2, C10.2, C11.2, U1.2, U1.3, U2.4 (GND)
IN: U1.1, U1.4, U2.5 (IN)
unnamed: C1.2, C3.2, C5.1, R1.1, R3.1
unnamed: C2.1, C4.1, R2.2, R4.2
unnamed: C2.2, C4.2, T1.3
unnamed: C3.1, C5.2, T1.1
unnamed: C7.1, D1.1 (K), D3.1 (K)
unnamed: C8.1, D2.2 (A), D4.2 (A)
unnamed: R2.1, R4.1, U1.7
unnamed: T1.4, U1.5
OUT+: C1.1, C6.1, D1.2 (A), D2.1 (K), R1.2, R3.2, U2.1 (OUT+)
OUT-: C6.2, C7.2, C8.2, D3.2 (A), D4.1 (K), T1.2, U2.2 (OUT-)

Board: 2 copper layers, 25.0 x 23.0 mm, 23 parts (0 on the bottom side), 14 nets.
