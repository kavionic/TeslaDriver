# Repository kavionic/TeslaDriver (continued)

## KiCad design Schematics/TeslaDriverHP/TeslaDriverHP.kicad_pcb

Parts:
C1, C2: 1000u/63V; C_Radial_D16_L25_P7.5
C3, C4: 2.2u/63V; C_Rect_L18_W8_P15
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28: 3n9/250V; C_0805
C29, C30: 100n; C_0603
D1, D2, D3, D4: SK520; DO-214AB
M1, M2, M3, M4: MountingHole; MH7x3
P1: PWR_IN+; PowerPad15_5_via
P2: PWR_GND; PowerPad15_5_via
P3: CONTROL; PinHeaderMale_2x08
P4: PWR_OUT_L1; PowerPad15_5_via
P5: PWR_OUT_L2; PowerPad15_5_via
Q1, Q2, Q3, Q4: IRFP4310ZPbF; TO-247
R1, R14, R15: 4k7; R_0603
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13: 1; R_2512
U1, U2, U3, U4: GateDriver; GateDriverMain
U5, U6: DS18B20; TO-92_Inline_Narrow_Oval

Connections:
+3V3: C29.1, C30.1, P3.12, R1.2, R14.1, R15.1, U5.3 (Vdd), U6.3 (Vdd)
+12V: P3.10, U1.3 (Vdd), U2.3 (Vdd), U3.3 (Vdd), U4.3 (Vdd)
+24V: C1.1, C2.1, C3.1, C4.1, D1.1 (K), D3.1 (K), P1.1, Q1.2 (D), Q3.2 (D), R2.2, R3.2, R4.2, R8.2, R9.2, R10.2
/GateEnable: P3.14, R1.1, U1.6 (EN), U2.6 (EN), U3.6 (EN), U4.6 (EN)
/GatePWM1H: P3.4, U1.5 (IN)
/GatePWM1L: P3.2, U2.5 (IN)
/GatePWM2H: P3.8, U3.5 (IN)
/GatePWM2L: P3.6, U4.5 (IN)
/OUTL1: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D1.2 (A), D2.1 (K), P4.1, Q1.3 (S), Q2.2 (D), U1.2 (OUT-)
/OUTL2: C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, D3.2 (A), D4.1 (K), P5.1, Q3.3 (S), Q4.2 (D), U3.2 (OUT-)
GND: C29.2, C30.2, P3.1, P3.3, P3.5, P3.7, P3.9, P3.11, P3.13, U1.4 (GND), U2.4 (GND), U3.4 (GND), U4.4 (GND), U5.1 (GND), U6.1 (GND)
GNDPWR: C1.2, C2.2, C3.2, C4.2, D2.2 (A), D4.2 (A), P2.1, Q2.3 (S), Q4.3 (S), R5.2, R6.2, R7.2, R11.2, R12.2, R13.2, U2.2 (OUT-), U4.2 (OUT-)
unnamed: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, R2.1, R3.1, R4.1
unnamed: C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, R5.1, R6.1, R7.1
unnamed: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, R8.1, R9.1, R10.1
unnamed: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, R11.1, R12.1, R13.1
unnamed: Q1.1 (G), U1.1 (OUT+)
unnamed: Q2.1 (G), U2.1 (OUT+)
unnamed: Q3.1 (G), U3.1 (OUT+)
unnamed: Q4.1 (G), U4.1 (OUT+)
TEMP_MOSFET1: P3.15, R14.2, U5.2 (DQ)
TEMP_MOSFET2: P3.16, R15.2, U6.2 (DQ)

Board: 2 copper layers, 80.0 x 100.0 mm, 68 parts (2 on the bottom side), 22 nets.

## KiCad design Schematics/TeslaDriver/TeslaDriver.kicad_pcb

Parts:
C1, C6, C7, C8, C9, C10, C11, C13, C15, C17, C19, C21, C23, C25, C29, C30, C31, C32, C34, C35, C36, C37: 100n; C_0603
C2, C3, C4, C5, C12, C14, C16, C18, C20, C22, C24, C26: 1u; C_0603
C27, C28: 1000u/63V; C_Radial_D16_L25_P7.5
C33, C38: 2.2u/63V; C_Rect_L18_W8_P15
D1, D2, D3, D4, D9, D10, D11, D12: ZMY12; MELF_Standard
D5, D6, D13, D14: SS210; Diode-SMA_Standard
D7, D8, D15, D16: SSA34; Diode-SMA_Standard
M1, M2, M3, M4: MountingHole; MH7x3
P1: CONTROL; PinHeaderMale_2x08
P2: PWR_IN+; PowerPad15_5
P3: PWR_GND; PowerPad15_5
P4: PWR_OUT_L1; PowerPad15_5
P5: PWR_OUT_L2; PowerPad15_5
Q1, Q2, Q3, Q4: STP65NF06; TO-220
R1, R2: 4k7; R_0603
R3, R4, R5, R6: 2; R_1206
T1, T2, T3, T4: GateTR10x4
U1, U2: DS18B20; TO-92_Inline_Narrow_Oval
U3, U4, U5, U6: NCP81071A; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3V3: C1.1, C10.1, P1.12, R1.1, R2.1, U1.3 (Vdd), U2.3 (Vdd)
+12V: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, P1.10, U3.1 (ENBA), U3.6 (VDD), U4.1 (ENBA), U4.6 (VDD), U5.6 (VDD), U5.8 (ENBB), U6.6 (VDD), U6.8 (ENBB)
+24V: C27.1, C28.1, C33.1, C38.1, P2.1, Q1.2 (D), Q3.2 (D)
/GatePWM1H: P1.4, U3.2 (INA), U3.8 (ENBB)
/GatePWM1L: P1.2, U4.2 (INA), U4.8 (ENBB)
/GatePWM2H: P1.8, U5.1 (ENBA), U5.4 (INB)
/GatePWM2L: P1.6, U6.1 (ENBA), U6.4 (INB)
/OUTL1: C29.2, C34.2, D1.2 (A), D9.1 (K), P4.1, Q1.3 (S), Q2.2 (D), T1.4 (S2)
/OUTL2: C31.2, C36.2, D3.2 (A), D11.1 (K), P5.1, Q3.3 (S), Q4.2 (D), T3.3 (S1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, P1.1, P1.3, P1.5, P1.7, P1.9, P1.11, P1.13, U1.1 (GND), U2.1 (GND), U3.3 (GND), U3.4 (INB), U4.3 (GND), U4.4 (INB), U5.2 (INA), U5.3 (GND), U6.2 (INA), U6.3 (GND)
GNDPWR: C27.2, C28.2, C30.2, C32.2, C33.2, C35.2, C37.2, C38.2, D2.2 (A), D4.2 (A), D10.1 (K), D12.1 (K), P3.1, Q2.3 (S), Q4.3 (S), T2.4 (S2), T4.3 (S1)
unnamed: C11.1, C12.1, U4.5 (OUTB)
unnamed: C11.2, C12.2, T2.1
unnamed: C13.1, C14.1, U6.7 (OUTA)
unnamed: C13.2, C14.2, T4.2
unnamed: C15.1, C16.1, U3.5 (OUTB)
unnamed: C15.2, C16.2, T1.1
unnamed: C17.1, C18.1, U5.7 (OUTA)
unnamed: C17.2, C18.2, T3.2
unnamed: C19.1, C20.2, T1.3 (S1)
unnamed: C19.2, C20.1, R3.1
unnamed: C21.1, C22.2, T2.3 (S1)
unnamed: C21.2, C22.1, R4.1
unnamed: C23.1, C24.2, T3.4 (S2)
unnamed: C23.2, C24.1, R5.1
unnamed: C25.1, C26.2, T4.4 (S2)
unnamed: C25.2, C26.1, R6.1
unnamed: C29.1, D1.1 (K), D5.1 (K)
unnamed: C30.1, D2.1 (K), D6.1 (K)
unnamed: C31.1, D3.1 (K), D7.1 (K)
unnamed: C32.1, D4.1 (K), D8.1 (K)
unnamed: C34.1, D9.2 (A), D13.2 (A)
unnamed: C35.1, D10.2 (A), D14.2 (A)
unnamed: C36.1, D11.2 (A), D15.2 (A)
unnamed: C37.1, D12.2 (A), D16.2 (A)
unnamed: D5.2 (A), D13.1 (K), Q1.1 (G), R3.2
unnamed: D6.2 (A), D14.1 (K), Q2.1 (G), R4.2
unnamed: D7.2 (A), D15.1 (K), Q3.1 (G), R5.2
unnamed: D8.2 (A), D16.1 (K), Q4.1 (G), R6.2
unnamed: T1.2, U3.7 (OUTA)
unnamed: T2.2, U4.7 (OUTA)
unnamed: T3.1, U5.5 (OUTB)
unnamed: T4.1, U6.5 (OUTB)
TEMP_MOSFET1: P1.15, R1.2, U1.2 (DQ)
TEMP_MOSFET2: P1.16, R2.2, U2.2 (DQ)

Board: 2 copper layers, 80.0 x 100.0 mm, 83 parts (0 on the bottom side), 45 nets.

## KiCad design Schematics/TeslaDriverHP2/QuadGateDriver.kicad_pcb

Parts:
C1, C6: 1u; C_0603
C2, C3, C4, C5, C9, C11, C12, C13, C16, C19, C20, C21, C23, C24, C25, C26: 100n; C_0603
C7, C8, C15, C18: NP; C_0603
C10, C14, C17, C22: 10u; C_1206
D1, D2, D5, D7: SMA6F12A; DO-221AC
D3, D4, D6, D8: DZ2J130M0L; SMini2-F5-B
D9: LED 0805 GREEN; LED_0805
P1: CUR_SENSE; PinHeader_1x02
P2: GDriver2H; SimpleGateDriverOut
P3: GDriver2L; SimpleGateDriverOut
P4: CONTROL; PinHeaderMale_2x10
P5: GDriver1H; SimpleGateDriverOut
P6: GDriver1L; SimpleGateDriverOut
R1, R2, R3, R4: 2R; R_1206
R5, R8, R9, R10, R12, R14, R15, R17: 3R9; R_1206
R6, R11, R13, R16: NP; R_0603
R7, R18, R19, R20, R21: 4k7; R_0603
R22: 180; R_0603
U1, U4: SI8233; SOIC-16_7.5x10.3mm_Pitch1.27mm
U2, U3, U5, U6: NXE2S1212MC; NXE2_DCDC
U7, U8, U9, U10: DS18B20; TO-92_Inline_Narrow_Oval
W1: 2HS; TestPoint06
W2: 2HG; TestPoint06
W3: 2HD; TestPoint06
W4: 2LS; TestPoint06
W5: 2LG; TestPoint06
W6: 2LD; TestPoint06
W7: IN2H; TestPoint06
W8, W10: IN2G; TestPoint06
W9: IN2L; TestPoint06
W11: IN1H; TestPoint06
W12, W14: IN1G; TestPoint06
W13: IN1L; TestPoint06
W15: 1HS; TestPoint06
W16: 1HG; TestPoint06
W17: 1HD; TestPoint06
W18: 1LS; TestPoint06
W19: 1LG; TestPoint06
W20: 1LD; TestPoint06
W21: CUR_N; TestPoint
W22: CUR_P; TestPoint

Connections:
+3V3: C23.1, C24.1, C25.1, C26.1, P4.12, R7.2, R18.1, R19.1, R20.1, R21.1, R22.2, U7.3 (Vdd), U8.3 (Vdd), U9.3 (Vdd), U10.3 (Vdd)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, P4.13, R6.1, R13.1, U1.3 (VDDI), U1.8 (VDDI), U4.3 (VDDI), U4.8 (VDDI)
+12V: C6.1, C11.1, C12.1, C19.1, C20.1, P4.10, U2.3 (+Vin), U3.3 (+Vin), U5.3 (+Vin), U6.3 (+Vin)
CUR_SENSE_N: P1.1, P4.19, R1.1, R2.1, R3.1, R4.1, W21.1
CUR_SENSE_P: P1.2, P4.20, R1.2, R2.2, R3.2, R4.2, W22.1
DT1: R13.2, R16.1, U4.6 (DT)
DT2: R6.2, R11.1, U1.6 (DT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C11.2, C12.2, C19.2, C20.2, C23.2, C24.2, C25.2, C26.2, D9.1 (K), P4.1, P4.3, P4.5, P4.7, P4.9, P4.11, R11.2, R16.2, U1.4 (GNDI), U2.1 (-Vin), U3.1 (-Vin), U4.4 (GNDI), U5.1 (-Vin), U6.1 (-Vin), U7.1 (GND), U8.1 (GND), U9.1 (GND), U10.1 (GND), W8.1, W10.1, W12.1, W14.1
GND1H: C15.2, C16.2, C17.2, D5.2 (A), D6.2 (A), P5.1 (Source), U4.9 (GNDB), U5.7 (-Vout), W15.1
GND1L: C21.2, C22.2, D8.2 (A), U4.14 (GNDA), U6.7 (-Vout)
GND2H: C7.2, C9.2, C10.2, D1.2 (A), D3.2 (A), P2.1 (Source), U1.9 (GNDB), U2.7 (-Vout), W1.1
GND2L: C13.2, C14.2, D4.2 (A), U1.14 (GNDA), U3.7 (-Vout)
IN1H: P4.4, U4.1 (INA), W11.1
IN1L: P4.2, U4.2 (INB), W13.1
IN2H: P4.8, U1.1 (INA), W7.1
IN2L: P4.6, U1.2 (INB), W9.1
unnamed: D9.2 (A), R22.1
unnamed: P2.2 (Drain), W3.1
unnamed: P3.2 (Drain), W6.1
unnamed: P5.2 (Drain), W17.1
unnamed: P6.2 (Drain), W20.1
OUT1H+: C15.1, D5.1 (K), P5.3 (Gate), R12.2, R14.2, W16.1
OUT1H+a: R12.1, R14.1, U4.10 (VOB)
OUT1L+: C18.2, D7.1 (K), P6.3 (Gate), R15.2, R17.2, W19.1
OUT1L+a: R15.1, R17.1, U4.15 (VOA)
OUT2H+: C7.1, D1.1 (K), P2.3 (Gate), R5.2, R8.2, W2.1
OUT2H+a: R5.1, R8.1, U1.10 (VOB)
OUT2L+: C8.2, D2.1 (K), P3.3 (Gate), R9.2, R10.2, W5.1
OUT2L+a: R9.1, R10.1, U1.15 (VOA)
TEMP_DIODE1: P4.17, R20.2, U9.2 (DQ)
TEMP_DIODE2: P4.18, R21.2, U10.2 (DQ)
TEMP_MOSFET1: P4.15, R18.2, U7.2 (DQ)
TEMP_MOSFET2: P4.16, R19.2, U8.2 (DQ)
VDD1H: C16.1, C17.1, D6.1 (K), U4.11 (VDDB), U5.8 (+Vout)
VDD1L: C18.1, C21.1, C22.1, D7.2 (A), D8.1 (K), P6.1 (Source), U4.16 (VDDA), U6.8 (+Vout), W18.1
VDD2H: C9.1, C10.1, D3.1 (K), U1.11 (VDDB), U2.8 (+Vout)
VDD2L: C8.1, C13.1, C14.1, D2.2 (A), D4.1 (K), P3.1 (Source), U1.16 (VDDA), U3.8 (+Vout), W4.1
~GATE_ENABLE: P4.14, R7.1, U1.5 (~EN), U4.5 (~EN)

Board: 2 copper layers, 46.0 x 37.0 mm, 95 parts (25 on the bottom side), 38 nets.

## Code that names these connections

File Firmware/TeslaDriver/TeslaDriver/Hardware.h:

// This file is part of TeslaDriver.
//
// Copyright (C) 2016 Kurt Skauen <http://kavionic.com/>
//
// TeslaDriver is free software : you can redistribute it and / or modify
// it under the terms of the GNU General Public License as published by
// the Free Software Foundation, either version 3 of the License, or
// (at your option) any later version.
//
// TeslaDriver is distributed in the hope that it will be useful,
// but WITHOUT ANY WARRANTY; without even the implied warranty of
// MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.See the
// GNU General Public License for more details.
//
// You should have received a copy of the GNU General Public License
// along with TeslaDriver. If not, see < http://www.gnu.org/licenses/>.
///////////////////////////////////////////////////////////////////////////////

#ifndef HARDWARE_H_
#define HARDWARE_H_

///////////////////////////////////////
// Ports:
//  PORTA
//   -PIN0(62)  : LCD (DB4)
//   -PIN1(63)  : LCD (DB5)
//   -PIN2(64)  : LCD (DB6)
//   -PIN3(1)   : LCD (DB7)
//   -PIN4(2)   : Zero Detect
//   -PIN5(3)   : Sense 5V
//   -PIN6(4)   : Sense 12V
//   -PIN7(5)   : Sense 48V
//  PORTB
//   -PIN0(6)   : LCD (RW)
//   -PIN1(7)   : LCD (RS)
//   -PIN2(8)   : Current Sense L
//   -PIN3(9)   : Current Window Out
//   -PIN4(10)  : Current Window In
//   -PIN5(11)  : Current Sense N
//   -PIN6(12)  : Quad decoder(1) phase 1
//   -PIN7(13)  : Quad decoder(3) phase 2
//  PORTC
//   -PIN0(16)  : PWM1H(2)
//   -PIN1(17)  : PWM1L(1)
//   -PIN2(18)  : PWM2L(3)
//   -PIN3(19)  : PWM2H(4)
//   -PIN4(20)  : SD_CS
//   -PIN5(21)  : SD_SCK
//   -PIN6(22)  : SC_MISO
//   -PIN7(23)  : SD_MOSI
//  PORTD
//   -PIN0(26)  : FAN1 PWM
//   -PIN1(27)  : FAN2 PWM
//  PORTE
//   -PIN0(36)  : FAN1 RPM
//   -PIN1(37)  : FAN2 RPM
//   -PIN2(38)  : Debug RXD
//   -PIN3(39)  : Debug TXD
//  PORTF
//   -PIN0(46)  : Temp sensor1
//   -PIN1(47)  : Temp sensor2
//   -PIN2(48)  : Temp Ext 1
//   -PIN3(49)  : Temp Ext 2
//   -PIN4(50)  : LCD (E)
//   -PIN5(51)  : WIFI RESET
//   -PIN6(54)  : WIFI UART(TX/22) WIFI->MCU
//   -PIN7(55)  : WIFI UART(RX/21) MCU->WIFI
//  PORTR

///////////////////////////////////////
// Event channels:
//  CH0 : Quad decoder.
//  CH1 : Modulation DMA trigger.
//  CH2 : PWM fault.
//  CH3
//  CH4 : Current sens low
//  CH5 : Current sens high
//  CH6 : FAN1 RPM
//  CH7 : FAN2 RPM

///////////////////////////////////////
// Timers:
//  TCC0    : Main PWM.
//   -TCC2
//  TCC1    : PWM modulation DMA trigger.
//
// TCD0     : PWM for FAN1/FAN2/LCD_CONTRAST/LCD_LED
//  -TCD2
// TCD1     : Buzzer
//
// TCE0     : System clock timer. / System timer (spin timer). / FAN1/FAN2 RPM capture.
//  -TCE2
// TCE1     : Quad decoder.
//
// TCF0     : Temperature sensor IO timer.
//  -TCF2

///////////////////////////////////////
// USART:
//  USARTC0
//  USARTC1
//  USARTD0
//  USARTD1
//  USARTE0 : Debugging.
//  USARTE1
//  USARTF0 : WIFI

///////////////////////////////////////
// AD Converters:
//  ADCA
//   -CH0   : V sense  5V
//   -CH1   : V sense 12V
//   -CH2   : V sense 48V
//   -CH3   : V sense 3.3V
//
//  ADCB
//   -CH0   : Current sense low.
//   -CH1   : Current sense high.
//   -CH2   : Current reference sense.
//   -CH3

///////////////////////////////////////
// DA Converters:
//  DACB
//   -CH0   : Current limit low
//   -CH1   : Current limit high

///////////////////////////////////////
// Analog Comparators:
//  ACA
//   -CH0
//   -CH1
//  ACB
//   -CH0   : Current limit high.
//   -CH1   : Current limit low.

#define CPU_FREQ 32000000
#define CLOCK_CPUCYCLES_PER_UPDATE    32768
#define CLOCK_PERIOD_BIT_COUNT      15

/// System timer //////////////////////////////////////////////////////////////

#define SYSTEM_TIMER TCE0

#define SPINTIMER_TIMERL SYSTEM_TIMER.CNTL
#define SPINTIMER_FREQ CPU_FREQ

/// Debug serial interface ////////////////////////////////////////////////////

#define DEBUG_USART USARTE0
#define DEBUG_USART_PORT e_DigitalPortID_E
#define DEBUG_USART_IN_PIN   PIN2_bm
#define DEBUG_USART_OUT_PIN  PIN3_bm

/// Quadrature decoder ////////////////////////////////////////////////////////

#define QUAD_DECODER_EVCH_MUX  EVSYS.CH0MUX
#define QUAD_DECODER_EVCH_CTRL EVSYS.CH0CTRL
#define QUAD_DECODER_TIMER_EVENT_SRC TC_EVSEL_CH0_gc

#define QUAD_DECODER_TIMER TCE1

#define QUAD_DECODER_PORT   e_DigitalPortID_B
#define QUAD_DECODER_PIN0   PIN6_bm
#define QUAD_DECODER_PIN1   PIN7_bm

/// Keyboard //////////////////////////////////////////////////////////////////

#define KEYBOARD_P0_PORT    e_DigitalPortID_E
#define KEYBOARD_P1_PORT    e_DigitalPortID_D
#define KEYBOARD_P2_PORT    e_DigitalPortID_D

#define KEYBOARD_P0_PIN     PIN4_bm
#define KEYBOARD_P1_PIN     PIN6_bm
#define KEYBOARD_P2_PIN     PIN7_bm

// Buzzer:
#define BUZZER_TIMER TCD1
#define BUZZER_PORT e_DigitalPortID_D
#define BUZZER_PIN1 PIN4_bm
#define BUZZER_PIN2 PIN5_bm

/// AD converters:
#define ADC_VSENSE3_3   ADCA.CH0
#define ADC_VSENSE5     ADCA.CH1
#define ADC_VSENSE12    ADCA.CH2
#define ADC_VSENSE48    ADCA.CH3

#define ADC_CURSENSE_LOW  ADCB.CH0
#define ADC_CURSENSE_HIGH ADCB.CH1
#define ADC_CURSENSE_REF  ADCB.CH2

/// Temperature sensor ////////////////////////////////////////////////////////

#define TEMP_SENS_TIMER TCF0
#define TEMP_SENS_PORT e_DigitalPortID_F

#define TEMP_SENS_PIN1    PIN0_bm
#define TEMP_SENS_PIN1_bp PIN0_bp

#define TEMP_SENS_PIN2    PIN1_bm
#define TEMP_SENS_PIN2_bp PIN1_bp

/// PWM peripherals ///////////////////////////////////////////////////////////

#define PWM_TIMER TCC0
#define PWM_OUT_PORT      e_DigitalPortID_C
#define PWM_LOW_PINS      (PIN1_bm | PIN2_bm)
#define PWM_HIGH_PINS     (PIN0_bm | PIN3_bm)
#define PWM_OUT_PINS      (PWM_LOW_PINS | PWM_HIGH_PINS)
#define PWM_AWEX_CHANNELS (AWEX_DTICCAEN_bm | AWEX_DTICCBEN_bm)

#define PWM_CMP_LO_PWM    CCABUF
#define PWM_CMP_HI_PWM    CCBBUF
#define PWM_CMP_MID       CCCBUF
//#define PWM_CMP_LO_SAMPLE CCCBUF
//#define PWM_CMP_HI_SAMPLE CCDBUF

//#define PWM_SAMPLE_LO_TRIG  EVSYS_CHMUX_TCC0_CCC_gc
//#define PWM_SAMPLE_HI_TRIG  EVSYS_CHMUX_TCC0_CCD_gc

#define PWM_SAMPLE_LO_TRIG  EVSYS_CHMUX_PORTC_PIN0_gc
#define PWM_SAMPLE_HI_TRIG  EVSYS_CHMUX_PORTC_PIN3_gc

#define PWM_MODULATION_TIMER TCC1

#define PWM_FAULT_EVENTS    BIT(2,1)

#define PWM_MODULATION_EVCH_MUX          EVSYS.CH1MUX
#define PWM_MODULATION_EVCH_CTRL         EVSYS.CH1CTRL
#define PWM_MODULATION_DMA_TRIGGER       DMA_CH_TRIGSRC_EVSYS_CH1_gc
#define PWM_MODULATION_EVENT_TRIGGER_SRC EVSYS_CHMUX_TCC1_OVF_gc

/// WIFI INTERFACE ////////////////////////////////////////////////////////////

#define WIFI_RADIO_RESET_PORT e_DigitalPortID_F
#define WIFI_RADIO_RESET_PIN  PIN5_bm

#define WIFI_RADIO_FLASHEN_PORT e_DigitalPortID_D
#define WIFI_RADIO_FLASHEN_PIN  PIN3_bm

#define WIFI_USART USARTF0
#define WIFI_USART_RX_INT USARTF0_RXC_vect
#define WIFI_USART_OUT_PORT e_DigitalPortID_F
#define WIFI_USART_IN_PIN   PIN6_bm
#define WIFI_USART_OUT_PIN  PIN7_bm

/// DISPLAY ///////////////////////////////////////////////////////////////////

#define DISPLAY_DATA_PORT            e_DigitalPortID_A

#define DISPLAY_REGISTER_SELECT_PORT e_DigitalPortID_B
#define DISPLAY_RW_PORT              e_DigitalPortID_B
#define DISPLAY_ENABLE_PORT          e_DigitalPortID_F

#define DISPLAY_REGISTER_SELECT PIN1_bm
#define DISPLAY_RW              PIN0_bm
#define DISPLAY_ENABLE          PIN4_bm

/// FAN CONTROL ///////////////////////////////////////////////////////////////
#define FAN_PWM_TIMER  TCD0
#define FAN_RPM_TIMER  TCE0

#define FAN_PWM_PORT    e_DigitalPortID_D
#define FAN_PWM1_PIN    PIN0_bm
#define FAN_PWM2_PIN    PIN1_bm
#define FAN_PWM_PERIOD (CPU_FREQ / 25000)

#define FAN_RPM_PORT    e_DigitalPortID_E
#define FAN_RPM1_PIN    PIN0_bm
#define FAN_RPM2_PIN    PIN1_bm

#include "ESP8266/ESP8266.h"
#include "Misc/Display.h"

void panic();

extern ESP8266    g_WifiDevice;
extern DisplayLCD g_Display;

#endif /* HARDWARE_H_ */

## Commit log

2016-06-21 Initial commit of firmware, support software, and CAD files for my tesla coil project.
2016-06-23 Decided to send the controller PCB off to China rather than etching myself. So fixed up the silkscreen and reduced via sizes a bit.
2016-06-23 Just ignored some binary files.
2016-06-28 * Redesigned the inverter gate driver. - It will now drive the gate to ~+-12V rather than ~-0.6 to 11.4. - Redesigned the gate clamping to better enforce the gate voltage limit and to more quickly ad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
    * Redesigned the inverter PCB.
    - Made an entirely new layout for the inverter PCB which hopefully
    will be able to carry substantial currents without needing extra
    bus bars. It should also give parasitic inductances on the board
    less oportunity to mess with the GS voltage.
    - Designed for manufacturing on a board-hose rather than home
2016-08-19 Did some small component value tweeks and sorted the BOM.
2016-08-19 - Some tweaks to the fan controller. - Added a lower-duty-cycle cap to keep it within the capabilities of the inverter. - Added slew-rate limiting to the PWM modulation. - Added support for fault con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
2016-08-19 Updated config version number.
2016-12-16 - Implemented a boot-loader with ESP8266 support allowing the firmware to be updated over WIFI. - Added support for firmware updates in the TeslaTuner application. - Implemented current measurement a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
2016-12-18 - The main projects now reference a local copy of the shared AVR framework. Makes it possible to change the framework APIs in one project without breaking the others (until they are being manually sy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
2016-12-18 - Changed the value of R30 & R31 to up the current sense reference voltage from 0.5V to 1.65V. - TeslaTuner now show current limits in Amps rather than a number between 0 and 4095.
2016-12-21 - Split ADC, DAC, and AC code out of PWMController and into a new class. - Configured ADCA to continousely sample all voltage rails in free-run mode. - At startup, the reference voltage for the curre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
2017-01-07 - Added support for reading the different voltage rail measurements over the WIFI protocol. - Added filtering of the current measurements. - Added support for reusing the ESP8266 setup after a softwa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
2017-01-07 - Added support for displaying the inverter power rail voltages. - Some tweaks to the UI layout.
2017-03-05 Revision 4 of TeslaDriver & revision 1 of QuadGateDriver.
2017-03-05 Archive copy of QuadGateDriver Rev 1.
